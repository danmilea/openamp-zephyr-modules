## zephyr/Kconfig
```kconfig
config ZEPHYR_LIBMETAL_MODULE
    bool
    default y

config ZEPHYR_OPEN_AMP_MODULE
    bool
    default y
```
